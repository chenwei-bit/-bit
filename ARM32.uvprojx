# Keil uVision project ARM32.uvprojx, settings and files
target ARM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM32 +hex
  AfterMake: D:\Users\Administrator\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin -o ./Objects/ARM32.bin ./Objects/ARM32.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm;.\Driver;.\GD32_Hal;.\GD32_Hal\Include;.\FreeRtos\port\MemMang;.\FreeRtos\port\RVDS\ARM_CM4F;.\FreeRtos\src;.\FreeRtos;.\FreeRtos\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c
  group Driver
    ./Driver/: key_drv.c gd32f30x_it.c led_drv.c systick.c usb2Com_drv.c
  group GD32_Hal
    ./GD32_Hal/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_exti.c gd32f30x_misc.c gd32f30x_usart.c
  group Arm
    ./Arm/: startup_gd32f30x_hd.s system_gd32f30x.c
  group FreeRTOS/SRC
    ./FreeRtos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/PORT
    ./FreeRtos/port/MemMang/: heap_4.c
    ./FreeRtos/port/RVDS/ARM_CM4F/: port.c
